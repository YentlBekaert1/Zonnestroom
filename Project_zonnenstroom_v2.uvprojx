# Keil uVision project Project_zonnenstroom_v2.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test_thuis
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F091RCTx/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F091RCTx/STCubeGenerated/Inc/: stm32f0xx_it.h
software components: CMSIS:CORE 5.4.0, Device:STM32Cube HAL 1.11.0
